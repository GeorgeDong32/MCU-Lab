		ORG		0000H
		LJMP	START
		ORG		0003H
		LJMP	IN0
		ORG		0013H
		LJMP	IN1
		ORG		0030H
START:	MOV		SP, #60H
		MOV		TCON, #05H
		SETB	EA
		SETB	EX0
		SETB	EX1
		SETB	PX1
		CLR		PX0
		MOV 	DPTR, #TABLE
		MOV		PSW, #00H
LOOP: 	ACALL	D0
		SJMP 	LOOP
D0:		MOV		R0, #6
		MOV		R2, #0
		MOV		R3, #0E7H  
D0LOOP:	INC		R3
		INC		R2
		MOV		A, R2
		MOVC 	A, @A+DPTR
		MOV 	P0, A
		MOV 	P1, R3
		MOV		R4, #200
D0DLY:	LCALL	DELAY
		DJNZ	R4, D0DLY 
		DJNZ	R0, D0LOOP
		RET
D1:		MOV		R0, #6
		MOV		R2, #0
		MOV		R3, #0E7H  
D1LOOP:	INC		R3
		MOV		DPTR, #NUM
		MOV		A, R2
		MOVC 	A, @A+DPTR
		MOV		DPTR, #TABLE
		MOVC	A, @A+DPTR
		MOV 	P0, A
		MOV 	P1, R3
		MOV		R4, #200
		INC		R2
D1DLY:	LCALL	DELAY
		DJNZ	R4, D1DLY 
		DJNZ	R0, D1LOOP
		RET
TABLE:	DB     	0C0H, 0F9H, 0A4H, 0B0H, 99H, 92H, 82H, 0F8H
		DB      80H, 90H, 88H, 83H, 0C6H, 0A1H, 86H, 8EH
NUM: 	DB		5, 1, 0, 0, 0, 0
IN0:	PUSH	ACC
		PUSH	PSW
		MOV		PSW, #10H
		ACALL	D1
		POP		PSW
		POP		ACC
		INC		R0
		DEC		R2
		DEC		R3
		RETI
IN1:	PUSH	ACC
		PUSH	PSW
		MOV		PSW, #18H
		MOV		R2, #1
		ACALL	D0
		POP		PSW
		POP		ACC
		INC		R0
		DEC		R2
		DEC		R3
		RETI
DELAY:	MOV 	R6, #4  
DEL1:	MOV 	R7, #229
DEL2:	DJNZ 	R7, DEL2
		DJNZ 	R6, DEL1
		RET
		END
