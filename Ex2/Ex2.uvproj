# Keil uVision project Ex2.uvproj, settings and files
target Ex2.1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Ex2.1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Ex2.1.asm
target Ex2.2 (MCS-51)
  device: STC89C52RC Series STC
  cpu: as above
  output: Ex2.2 +hex
  c flags: Optimize=8 SizeSpeed=1
target Ex2.3 (MCS-51)
  device: STC89C52RC Series STC
  cpu: as above
  output: Ex2.3 +hex
  c flags: Optimize=8 SizeSpeed=1
